# IAR project Keycore.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: src; lib\CMSIS\Device\ST\STM32F10x; lib\CMSIS\Device\ST\STM32F10x\Include; lib\CMSIS\Include; lib\STM32F10x_StdPeriph_Driver\inc; lib\Crypto\ed25519; lib\Crypto\sha3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Keycore.hex
  ILINK.IlinkOutputFile: Keycore.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group Application
    src/: cmd_handler.c keycore.c keys.c main.c serial.c stm32f10x_it.c system.c utils.c
  group CMSIS
    lib/CMSIS/Device/ST/STM32F10x/: system_stm32f10x.c
  group Libraries/Cryptographic/Ed25519
    lib/Crypto/ed25519/: ed25519.h fe.c fe.h fixedint.h ge.c ge.h keypair.c precomp_data.h sc.c sc.h sign.c verify.c
  group Libraries/Cryptographic/SHA3
    lib/Crypto/sha3/: sha3.c sha3.h
  group Libraries/StdPeriph/stm32f10x
    lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    lib/CMSIS/Device/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
